options:
  parameters:
    author: krono
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: spoof1090_adsb_mod_async_0
  id: spoof1090_adsb_mod_async
  parameters: {}
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '100'
  states: {}

connections:
- [spoof1090_adsb_mod_async_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0, out, spoof1090_adsb_mod_async_0, in]

metadata:
  file_format: 1
